FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://cog-set-opaque-region_v0.14.patch"
