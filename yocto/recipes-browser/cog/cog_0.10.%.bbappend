FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://cog-set-opaque-region_v0.10.patch"
